<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TP_A_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\TP2_A_2\TP_A_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


